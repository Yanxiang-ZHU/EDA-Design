I1 1 4 10
V1 4 5 1
R1 6 5 10
R2 7 8 1
R3 8 9 1
V2 9 10 1
V3 11 12 1
