R1 0 1 1k
R2 1 2 1k
C1 2 3 0.001u
C2 3 4 0.001u
L1 4 5 10mH
L2 5 0 10mH
V1 0 0 10V
V2 0 5 10V
I1 0 2 5mA
I2 1 4 5mA
