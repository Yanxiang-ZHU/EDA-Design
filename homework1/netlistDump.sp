C0 0 1 0.001u
L0 1 0 10mH
V0 0 1 10V
I0 0 1 5mA
I1 0 1 5mA
R0 0 2 1k
C1 2 3 0.001u
L1 3 0 10mH
V1 0 2 10V
I2 0 3 5mA
R1 0 4 1k
R2 4 5 1k
R3 5 0 1k
V2 0 4 10V
I3 4 0 5mA
V3 0 6 10V
