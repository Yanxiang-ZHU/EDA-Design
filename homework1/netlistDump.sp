R0 0 0 1k
C0 0 2 0.001u
L0 2 0 10mH
V0 0 0 10V
I0 0 2 5mA
R1 0 3 1k
R2 3 4 1k
C1 4 0 0.001u
V1 0 3 10V
I1 0 3 5mA
R3 0 0 1k
L1 0 0 10mH
V2 0 0 10V
I2 0 0 5mA
I3 0 0 5mA
V3 0 6 10V
