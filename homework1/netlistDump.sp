R1 0 1 1k
R2 1 2 1k
C1 2 3 0.001u
C2 3 4 0.001u
L1 4 5 10mH
L2 5 0 10mH
V1 0 4 10V
V2 0 3 10V
I1 1 3 5mA
I2 4 2 5mA
