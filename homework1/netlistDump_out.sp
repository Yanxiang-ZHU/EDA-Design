R0 0 1 1k
L0 1 0 10mH
V0 0 1 10V
I0 0 1 5mA
R1 0 2 1k
R2 2 0 1k
C0 0 0 0.001u
V1 0 0 10V
I1 2 0 5mA
R3 0 4 1k
C1 4 5 0.001u
L1 5 0 10mH
V2 0 4 10V
I2 4 0 5mA
I3 0 4 5mA
V3 0 6 10V
